# Repository ramonimbao/squatterboard-v1.5

File README.md:

# Squatterboard V1.5

This repository is a mix between [Croktopus' squatterboard](https://github.com/Croktopus/squatterboard), [xyz's b-ken-ko daughterboard](https://github.com/xyzz/b-ken-ko/tree/main/dboard), and [my fork of the squatterboard](https://github.com/ramonimbao/squatterboard).

Calling this V2 might be confusing since [there's already a second version of it](https://github.com/Croktopus/squatterboard2), so I renamed it to V1.5.

## Features

- ai03 unified daughterboard standard
- OG Squatterboard JST and USB positioning
- b-ken-ko dboard thinness
- Compatible with my fork of the squatterboard, but can be assembled by JLCPCB.

## Ordering singles

Don't know if you can with JLCPCB. Gerbers and BOM/CPL assembly files are in `gerbers-v2`.

## Ordering panelized

Gerbers for a 2 rows × 8 cols panel are in the `panelized` folder.

Order from JLCPCB as a `Panel by Customer` but specify BOM/CPL file as for a single board. BOM/CPL assembly files located in `gerbers-v2`.

## KiCad design Unified-Daughterboard.kicad_pcb

Parts:
C1: 4.7n; C_0603_1608Metric; LCSC C53987
G1: Signature; Signature_ExtraSmall
J1: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-jlc; LCSC C165948
J2: Conn_01x04; JST-SR-4
MH1, MH2: Mount-M2; MountingHole_3.2mm_M3_Pad_Via
R1, R2: 5.1k; R_0603_1608Metric; LCSC C23186
R3: 1M; R_0805_2012Metric; LCSC C17514

Connections:
D+: J1.6 (DP1), J1.8 (DP2), J2.3
D-: J1.5 (DN2), J1.7 (DN1), J2.2
GND: C1.1, J1.1 (GND), J1.12 (GND), J2.4, J2.MP (MountPin), R1.2, R2.2, R3.1
unnamed: J1.4 (CC1), R2.1
unnamed: J1.10 (CC2), R1.1
SHIELD: C1.2, J1.13 (SHIELD), MH1.1, MH2.1, R3.2
VCC: J1.2 (VBUS), J1.11 (VBUS), J2.1

Board: 2 copper layers, 46.7 x 8.7 mm, 9 parts (7 on the bottom side), 7 nets.

File gerbers-v2/Unified-Daughterboard-BOM.csv:

Comment,Designator,Footprint,LCSC
"4.7n","C1","Capacitor_SMD:C_0603_1608Metric","C53987"
"Signature","G1","Ramon:Signature_Small",""
"HRO-TYPE-C-31-M-12","J1","Type-C:HRO-TYPE-C-31-M-12-jlc","C165948"
"Conn_01x04","J2","random-keyboard-parts:JST-SR-4",""
"Mount-M2","MH1,MH2","MountingHole:MountingHole_3.2mm_M3_Pad_Via",""
"5.1k","R1,R2","Resistor_SMD:R_0603_1608Metric","C23186"
"1M","R3","Resistor_SMD:R_0805_2012Metric","C17514"

## Commit log

2022-06-16 Update fill in panel
